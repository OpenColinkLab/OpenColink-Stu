//--------------------------------------------------------------------------------
/* //-----------------------------------------------------------------------------
 * Organization: XDU				    ██████╗██╗  ██╗███████╗██╗███████╗██████╗
 * Engineer: Chsier                    ██╔════╝██║  ██║██╔════╝██║██╔════╝██╔══██╗
 * E-mail: 1481154662@qq.com           ██║     ███████║███████╗██║█████╗  ██████╔╝
 * Cnblogs: www.cnblogs.com/chsier     ██║     ██╔══██║╚════██║██║██╔══╝  ██╔══██╗
 *                                     ╚██████╗██║  ██║███████║██║███████╗██║  ██║
 * Create Date: 25-05-22 13:19:35
 * File Name: elstr.c
 * Module Name:
 * Target Devices: *
 * Tool Versions: VScode
 *
 * Versions | Modify
 * ------------------
 * v-alpha  | 25-05-22
 * ------------------
 * Description:
 *
 *
 */
//-----------------------------------------------------------------------------
//---------------------------------------------------------------------------------

/*---------------------------*\
			Include
\*---------------------------*/
#include "elstr.h"

#ifdef __cplusplus
extern "C"
{
#endif // Compatible C++

	/*-------------------------------------------------------*\
						  Static PV
	\*-------------------------------------------------------*/

	/*-------------------------------------------------------*\
					Static fun declaration
	\*-------------------------------------------------------*/

	/*-------------------------------------------------------*\
					Static function body
	\*-------------------------------------------------------*/

	/*-------------------------------------------------------*\
					Extern function body
	\*-------------------------------------------------------*/

	int32_t elstrcmp(const char *s1, const char *s2)
	{ /* compare unsigned char s1[], s2[] */
		for (; *s1 == *s2; ++s1, ++s2)
			if (*s1 == '\0')
				return (0);
		return (*(unsigned char *)s1 < *(unsigned char *)s2
					? -1
					: +1);
	}

	char *elstrncpy(char *s1, const char *s2, uint32_t n)
	{ /* copy char s2[max n] to s1[n] */
		char *s;

		for (s = s1; 0 < n && *s2 != '\0'; --n)
			*s++ = *s2++; /* copy at most n chars from s2[] */
		for (; 0 < n; --n)
			*s++ = '\0';
		return (s1);
	}

	uint32_t elstrlen(const char *s)
	{ /* find length of s[] */
		const char *sc;

		for (sc = s; *sc != '\0'; ++sc)
			;
		return (sc - s);
	}

#ifdef __cplusplus
}
#endif // Compatible C++