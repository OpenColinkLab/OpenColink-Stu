# Keil uVision project Comp_Application.uvprojx, settings and files
target Comp_Application (6140000::V6.14::ARMCLANG)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Comp_Application +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSP432P401R__,ARM_MATH_CM4,__FPU_PRESENT=1,__TARGET_FPU_VFP,DBG_MOD,_MSC_VER
  c include: .\Library\device\inc;.\Library\device;.\Library\cmsis_dsp\inc;.\Library\driverlib\inc;.\Library\sol_driver\assist;.\Library\sol_driver\bsp\inc;.\Library\sol_driver\global;.\Library\sol_driver\project\inc;.\Library\sol_driver\sol_device\inc;.\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ./Source/: main.c system_msp432p401r.c startup_msp432p401r_uvision.s
  group cmsis_dsp
    ./Library/cmsis_dsp/Lib/: arm_cortexM4lf_math.lib
  group driverlib
    ./Library/driverlib/Src/: cpu.c cs.c interrupt.c sysctl.c wdt_a.c flash.c flash_a.c uart.c gpio.c pcm.c rtc_c.c fpu.c adc14.c i2c.c dma.c
  group sol_driver\bsp
    ./Library/sol_driver/bsp/src/: bsp_buffer.c bsp_adc14.c bsp_delay.c bsp_ref.c bsp_gpio.c bsp_uart.c bsp_dma.c bsp_setup.c bsp_timerA.c bsp_interrupt.c
  group sol_driver\assist
    ./Library/sol_driver/assist/: ast_debug.c ast_error.c ast_other.c
  group sol_driver\sol_device
    ./Library/sol_driver/sol_device/src/: dev_at24cxx.c dev_beep.c dev_dac_tlv5638.c dev_dsp_ext.c dev_hmi.c dev_i2c_sim.c dev_max262_pcf.c dev_mkey_74hc165.c dev_relay.c dev_spi_sim.c dev_switch_ch444g.c dev_w25qxx.c
  group sol_driver\project
    ./Library/sol_driver/project/src/: fsm.c hamster_plate.c project_main.c
software components: CMSIS:CORE 5.4.0
